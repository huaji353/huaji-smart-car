# Keil uVision project seekfree.uvproj, settings and files
target AI8051U_32bit (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  asm include: ..\..\libraries\zf_common
  link misc: REMOVEUNUSED
  group zf_common
    ../../libraries/zf_common/: ai8051u_32bit.h ai8051u_isr.asm zf_common_headfile.h zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_typedef.c zf_common_typedef.h zf_common_interrupt.c zf_common_interrupt.h START251.A51
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_eeprom.c zf_driver_eeprom.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h
  group zf_device
    ../../libraries/zf_device/: zf_device_type.c zf_device_type.h zf_device_ips200.c zf_device_ips200.h zf_device_ble6a20.c zf_device_ble6a20.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_config.c zf_device_config.h
  group zf_components
    ../../libraries/zf_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group user
    ../user/: isr.c isr.h main.c
  group code
    ../code/: command.c command.h key.c key.h menu.c menu.h IMU.c IMU.h contrl.c contrl.h set_task.c set_task.h image.c image.h
  group doc
    ../../libraries/doc/: version.txt
